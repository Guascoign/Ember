# Keil uVision project Ember_F405.uvprojx, settings and files
target Ember_F405 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F405RGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x80FFFFF)  CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Ember +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F405xx
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../Drivers;../Middlewares_User/FreeRTOS/include;../Middlewares_User/FreeRTOS/portable/RVDS/ARM_CM4F;../Middlewares_User/LVGL/GUI;../Middlewares_User/LVGL/GUI/lvgl;../Middlewares_User/LVGL/GUI/lvgl/examples/porting;../Middlewares_User/LVGL/GUI/lvgl/src;../Middlewares_User/LVGL/GUI_APP/demos;../Middlewares_User/LVGL/GUI_APP/demos/stress;../Middlewares_User/LVGL/GUI_APP/GUI_Guider/generated;../Middlewares_User/LVGL/GUI_APP/GUI_Guider/custom;../Middlewares_User/LVGL/GUI_APP/demos/benchmark
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f405xx.s
  group Application/User/Core
    ../Core/Src/: FreeRTOS_main.c main.c gpio.c adc.c dma.c spi.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_ll_adc.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_spi.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Middlewares/FreeRTOS
    ../Middlewares_User/FreeRTOS/include/: FreeRTOSConfig.h
    ../Middlewares_User/FreeRTOS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares_User/FreeRTOS/portable/MemMang/: heap_4.c
    ../Middlewares_User/FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
  group Middlewares/LVGL/demo
    ../Middlewares_User/LVGL/GUI_APP/demos/benchmark/assets/: img_benchmark_cogwheel_alpha16.c img_benchmark_cogwheel_argb.c img_benchmark_cogwheel_chroma_keyed.c img_benchmark_cogwheel_indexed16.c img_benchmark_cogwheel_rgb.c img_benchmark_cogwheel_rgb565a8.c lv_font_bechmark_montserrat_12_compr_az.c.c lv_font_bechmark_montserrat_16_compr_az.c.c lv_font_bechmark_montserrat_28_compr_az.c.c
    ../Middlewares_User/LVGL/GUI_APP/demos/benchmark/: lv_demo_benchmark.c
  group Middlewares/LVGL/src
    ../Middlewares_User/LVGL/GUI/lvgl/: lv_conf.h
    ../Middlewares_User/LVGL/GUI/lvgl/examples/porting/: lv_port_fs_template.c lv_port_fs_template.h lv_port_disp_template.c lv_port_disp_template.h lv_port_indev_template.c lv_port_indev_template.h
    ../Middlewares_User/LVGL/GUI/lvgl/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
    ../Middlewares_User/LVGL/GUI/lvgl/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_img.c lv_draw_label.c lv_draw_layer.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_transform.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
    ../Middlewares_User/LVGL/GUI/lvgl/src/draw/arm2d/: lv_gpu_arm2d.c
    ../Middlewares_User/LVGL/GUI/lvgl/src/draw/renesas/: lv_gpu_d2_draw_label.c lv_gpu_d2_ra6m3.c
    ../Middlewares_User/LVGL/GUI/lvgl/src/draw/sdl/: lv_draw_sdl.c lv_draw_sdl_arc.c lv_draw_sdl_bg.c lv_draw_sdl_composite.c lv_draw_sdl_img.c lv_draw_sdl_label.c lv_draw_sdl_layer.c lv_draw_sdl_line.c lv_draw_sdl_mask.c lv_draw_sdl_polygon.c lv_draw_sdl_rect.c lv_draw_sdl_stack_blur.c lv_draw_sdl_texture_cache.c lv_draw_sdl_utils.c
    ../Middlewares_User/LVGL/GUI/lvgl/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_dither.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_layer.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c lv_draw_sw_transform.c
    ../Middlewares_User/LVGL/GUI/lvgl/src/draw/swm341_dma2d/: lv_gpu_swm341_dma2d.c
    ../Middlewares_User/LVGL/GUI/lvgl/src/extra/layouts/flex/: lv_flex.c
    ../Middlewares_User/LVGL/GUI/lvgl/src/extra/layouts/grid/: lv_grid.c
    ../Middlewares_User/LVGL/GUI/lvgl/src/extra/libs/bmp/: lv_bmp.c
    ../Middlewares_User/LVGL/GUI/lvgl/src/extra/libs/ffmpeg/: lv_ffmpeg.c
    ../Middlewares_User/LVGL/GUI/lvgl/src/extra/libs/freetype/: lv_freetype.c
    ../Middlewares_User/LVGL/GUI/lvgl/src/extra/libs/fsdrv/: lv_fs_fatfs.c lv_fs_littlefs.c lv_fs_posix.c lv_fs_stdio.c lv_fs_win32.c
    ../Middlewares_User/LVGL/GUI/lvgl/src/extra/libs/gif/: gifdec.c lv_gif.c
    ../Middlewares_User/LVGL/GUI/lvgl/src/extra/libs/png/: lodepng.c lv_png.c
    ../Middlewares_User/LVGL/GUI/lvgl/src/extra/libs/qrcode/: lv_qrcode.c qrcodegen.c
    ../Middlewares_User/LVGL/GUI/lvgl/src/extra/libs/rlottie/: lv_rlottie.c
    ../Middlewares_User/LVGL/GUI/lvgl/src/extra/libs/sjpg/: lv_sjpg.c tjpgd.c
    ../Middlewares_User/LVGL/GUI/lvgl/src/extra/libs/tiny_ttf/: lv_tiny_ttf.c
    ../Middlewares_User/LVGL/GUI/lvgl/src/extra/others/fragment/: lv_fragment.c lv_fragment_manager.c
    ../Middlewares_User/LVGL/GUI/lvgl/src/extra/others/gridnav/: lv_gridnav.c
    ../Middlewares_User/LVGL/GUI/lvgl/src/extra/others/ime/: lv_ime_pinyin.c
    ../Middlewares_User/LVGL/GUI/lvgl/src/extra/others/imgfont/: lv_imgfont.c
    ../Middlewares_User/LVGL/GUI/lvgl/src/extra/others/monkey/: lv_monkey.c
    ../Middlewares_User/LVGL/GUI/lvgl/src/extra/others/msg/: lv_msg.c
    ../Middlewares_User/LVGL/GUI/lvgl/src/extra/others/snapshot/: lv_snapshot.c
    ../Middlewares_User/LVGL/GUI/lvgl/src/extra/themes/basic/: lv_theme_basic.c
    ../Middlewares_User/LVGL/GUI/lvgl/src/extra/themes/default/: lv_theme_default.c
    ../Middlewares_User/LVGL/GUI/lvgl/src/extra/themes/mono/: lv_theme_mono.c
    ../Middlewares_User/LVGL/GUI/lvgl/src/extra/widgets/animimg/: lv_animimg.c
    ../Middlewares_User/LVGL/GUI/lvgl/src/extra/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../Middlewares_User/LVGL/GUI/lvgl/src/extra/widgets/chart/: lv_chart.c
    ../Middlewares_User/LVGL/GUI/lvgl/src/extra/widgets/colorwheel/: lv_colorwheel.c
    ../Middlewares_User/LVGL/GUI/lvgl/src/extra/widgets/imgbtn/: lv_imgbtn.c
    ../Middlewares_User/LVGL/GUI/lvgl/src/extra/widgets/keyboard/: lv_keyboard.c
    ../Middlewares_User/LVGL/GUI/lvgl/src/extra/widgets/led/: lv_led.c
    ../Middlewares_User/LVGL/GUI/lvgl/src/extra/widgets/list/: lv_list.c
    ../Middlewares_User/LVGL/GUI/lvgl/src/extra/widgets/menu/: lv_menu.c
    ../Middlewares_User/LVGL/GUI/lvgl/src/extra/widgets/meter/: lv_meter.c
    ../Middlewares_User/LVGL/GUI/lvgl/src/extra/widgets/msgbox/: lv_msgbox.c
    ../Middlewares_User/LVGL/GUI/lvgl/src/extra/widgets/span/: lv_span.c
    ../Middlewares_User/LVGL/GUI/lvgl/src/extra/widgets/spinbox/: lv_spinbox.c
    ../Middlewares_User/LVGL/GUI/lvgl/src/extra/widgets/spinner/: lv_spinner.c
    ../Middlewares_User/LVGL/GUI/lvgl/src/extra/widgets/tabview/: lv_tabview.c
    ../Middlewares_User/LVGL/GUI/lvgl/src/extra/widgets/tileview/: lv_tileview.c
    ../Middlewares_User/LVGL/GUI/lvgl/src/extra/widgets/win/: lv_win.c
    ../Middlewares_User/LVGL/GUI/lvgl/src/extra/: lv_extra.c
    ../Middlewares_User/LVGL/GUI/lvgl/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c
    ../Middlewares_User/LVGL/GUI/lvgl/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
    ../Middlewares_User/LVGL/GUI/lvgl/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
    ../Middlewares_User/LVGL/GUI/lvgl/src/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_line.c lv_objx_templ.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c
  group Middlewares/LVGL/GUI
    ../Middlewares_User/LVGL/GUI_APP/GUI_Guider/generated/: events_init.c gui_guider.c setup_scr_screen_1.c setup_scr_screen_2.c widgets_init.c
    ../Middlewares_User/LVGL/GUI_APP/GUI_Guider/generated/guider_fonts/: lv_font_Youshebiaotihei_10.c lv_font_Youshebiaotihei_16.c lv_font_Youshebiaotihei_20.c
    ../Middlewares_User/LVGL/GUI_APP/GUI_Guider/generated/images/: _indent_alpha_20x20.c _windowsxp_alpha_198x89.c
  group BSP/Peripherals
    ../Drivers/BSP/Peripherals/: Peripherals.c
    ../Drivers/BSP/GPIO/: led_device.c gpio_device.c key_device.c
    ../Drivers/BSP/UART/: uart_device.c uart_printf.c
    ../Drivers/BSP/RGB/: rgb_device.c
    ../Drivers/BSP/IIC/: iic_device.c
    ../Drivers/BSP/EEPROM/: at24cxx.c
    ../Drivers/BSP/BEEPER/: beeper_device.c
  group LIB
    ../Drivers/LIB/: circle_buffer.c soft_timer.c
  group BSP/LCD
    ../Drivers/BSP/LCD/: lcd.c st7789.c lcd_consle.c
software components: CMSIS:CORE 6.1.0
